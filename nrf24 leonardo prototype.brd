File: nrf24 leonardo prototype.brd (EAGLE design)
At the start: 68.6 x 50.8 mm, 5 parts

Commit message: Update
Just moved a few things
Other:
- board size 68.6 x 50.8 mm -> 68.6 x 51.4 mm
